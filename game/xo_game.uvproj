# Keil uVision project xo_game.uvproj, settings and files
target xo_game (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: xo_game
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source files
    ./src/: startup.s leds.c Nokia5110.c operations.c ports.c screens.c TExaS.c timers.c UART.c
    ./: xo.c
    ./headers/: ports_cfg.c ports_cfg.h
  group New Group
    ./headers/: leds.h Nokia5110.h operations.h ports.h screens.h shapes.h TExaS.h timers.h tm4c123gh6pm.h xo.h Types.h UART.h
    ./common/: BIT_MATH.h GameArt.h XO Game.h
    ./src/: timer_cfg.c
